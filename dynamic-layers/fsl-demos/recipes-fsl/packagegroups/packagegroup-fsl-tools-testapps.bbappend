SOC_TOOLS_TEST_remove = "imx-test"
