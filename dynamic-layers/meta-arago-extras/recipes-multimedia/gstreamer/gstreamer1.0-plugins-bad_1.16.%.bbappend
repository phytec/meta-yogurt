PACKAGECONFIG_remove_am57xx = "faad"
