FILESEXTRAPATHS_prepend := "${THISDIR}/bison:"

SRC_URI += "\
    file://110-glibc-change-work-around.patch \
"
