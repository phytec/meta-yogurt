SRC_URI_remove = "git://git.kernel.org/pub/scm/linux/kernel/git/shemminger/bridge-utils.git;branch=master"
SRC_URI =+ "git://git.kernel.org/pub/scm/network/bridge/bridge-utils.git;branch=main"
