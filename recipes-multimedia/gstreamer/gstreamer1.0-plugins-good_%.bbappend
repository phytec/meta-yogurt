PACKAGECONFIG_append_k3 = " vpx"
PACKAGECONFIG_append_am57xx = " vpx"
