# Use hardware cryptography accelerators
PACKAGECONFIG_append_am57xx = " cryptodev-linux"
